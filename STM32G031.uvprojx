# Keil uVision project STM32G031.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32G031F8Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32G031
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Sources
    ./: main.c leds.c buttons.c
  group Headers
    ./: leds.h buttons.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.4.0
